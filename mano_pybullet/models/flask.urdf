Commit message: 2 body flask

File: mano_pybullet/models/flask.urdf (robot description, URDF)
Before this commit: robot flask, 3 links, 2 joints
Links:
- removed link flask_lid
- removed link lid_intermediate
Joints:
- removed joint lift_joint
- removed joint twist_joint

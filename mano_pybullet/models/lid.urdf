Commit message: finished simulation

File: mano_pybullet/models/lid.urdf (robot description, URDF)
Before this commit: robot lid, 1 links, 0 joints
Links:
- link top: geometry collision cylinder length=0.02 radius=0.055; visual cylinder length=0.02 radius=0.05
